# Keil uVision project STM32F407VGT6_Template.uvprojx, settings and files
target STM32F407VGT6_Template (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32F407_FLASH_RELEASE +hex
  BeforeMake: ..\tools\make_res_image.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_USBD_COMPOSITE
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/lcd;../RTT;../FreeRTOS;../FreeRTOS/include;../User/key;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../User/test;../FreeRTOS/port/GCC/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/COMPOSITE/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MIDI/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../User/fs;../User/apps;../User/led;../User/ui_framework/config;../User/ui_framework/include;../User/ui_framework/include/common;../User/ui_framework/include/font;../User/ui_framework/include/res;../User/ui_framework/include/ui;../User/ui_framework/include/ui/cpu/br27;../User/ui_framework/include/ui/cpu/br27/asm;../User/ui_framework/include/ui_draw;../User/ui_framework/include/ui_vm;../User/ui_framework/port/bsp;../User/ui_framework/port/bsp/stm32f4;../User/ui_framework/port/res;../User/ui_framework/port/rtos;../User/ui_framework/ui_action;../User/dcx_ui_action
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\FLASH_RELEASE\STM32F407_FLASH_RELEASE.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../User/lcd/: lcd.c text.c
    ../User/key/: iokey.c key_driver.c
    ../User/apps/: app_core.c
    ../User/led/: app_led.c
    ../Core/Src/: main.c gpio.c dma.c i2s.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../User/fs/: flash_disk.c res_image.c
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Debug/RTT
    ../RTT/: log_debug.h log_debug.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/: FreeRTOSConfig.h
    ../FreeRTOS/port/GCC/ARM_CM4F/: port.c
  group FreeRTOS/User
    ../FreeRTOS/: circular_buf.c task_manager.c FreeRTOSHook.c
  group Application/User/Test
    ../User/test/: fs_test.c iis_test.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usbd_storage_if.c usbd_cdc_if.c usbd_audio_if.c usbd_midi_if.c usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/COMPOSITE/Src/: usbd_composite.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Src/: usbd_composite_builder.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MIDI/Src/: usbd_midi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group UI/liba/common
    ../User/ui_framework/liba/common/: jl_ascii.c jl_crc.c jl_debug.c
  group UI/port
    ../User/ui_framework/port/res/fatfs/: ui_res_fatfs.c
    ../User/ui_framework/config/: ui_port_registry.c ui_config.c
    ../User/ui_framework/liba/common/: ui_port_stubs.c
    ../User/ui_framework/port/bsp/stm32f4/: ui_lcd_stm32f4.c
  group UI/lcd_drive/middle
    ../User/ui_framework/lcd_drive/middle/: lcd_ui_api.c ui_platform.c ui_pushScreen_manager.c ui_resources_manager.c ui_synthesis_oled.c
  group UI/lcd_drive
    ../User/ui_framework/lcd_drive/: oled_spi_ssd1306_128x64.c
  group UI/liba/ui_dot
    ../User/ui_framework/liba/ui_dot/: layer.c layout.c lyrics.c ui_battery.c ui_core_api.c ui_core_dot.c ui_grid.c ui_number.c ui_p.c ui_pic.c ui_rotate.c ui_slider.c ui_slider_vert.c ui_text.c ui_time.c window.c
  group UI/liba/font
    ../User/ui_framework/liba/font/: font_ascii.c font_big5.c font_gbk.c font_ksc.c font_other_language.c font_sdfs.c font_sjis.c font_textout.c utf8_2_unicode.c
  group UI/liba/ui_draw
    ../User/ui_framework/liba/ui_draw/: image_process.c ui_circle.c
  group UI/liba/res
    ../User/ui_framework/liba/res/: ascii.c mem_var.c quicklz.c resfile.c rle.c ui_res_core.c
  group UI/dcx_ui_action
    ../User/dcx_ui_action/: boot_action.c input_action.c output_action.c setup_action.c sum_action.c mute_action.c recall_action.c store_action.c ptest_action.c
target RAM_Debug (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407_RAM_DEBUG +hex
  BeforeMake: ..\tools\make_res_image.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,RAM_DEBUG=1,USE_USBD_COMPOSITE1
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\RAM_DEBUG\STM32F407_RAM_DEBUG.sct
